# Keil uVision project LCD.uvproj, settings and files
target Target (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: LCD.c main.c util.c
  group Header
    ./: font.h IAP15.h LCD.h util.h
